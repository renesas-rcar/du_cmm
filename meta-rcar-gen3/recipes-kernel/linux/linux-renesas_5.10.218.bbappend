SRC_URI += " \
    file://0001-drm-rcar-du-Add-DU-CMM-support.patch \
    file://0002-drm-rcar-du-cmm-use-atomic-for-vsync-instead-of-spin.patch \
    file://0003-drm-rcar-du-cmm-check-hardware-buffer-side-of-lut-cl.patch \
"
