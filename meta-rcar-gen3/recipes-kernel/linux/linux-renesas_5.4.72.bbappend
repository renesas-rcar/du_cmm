SRC_URI += " \
    file://0001-drm-rcar-du-Add-DU-CMM-support.patch \
"

